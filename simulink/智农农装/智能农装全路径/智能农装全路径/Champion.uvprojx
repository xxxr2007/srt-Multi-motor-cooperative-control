# Keil uVision project Champion.uvprojx, settings and files
target Champion (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: znnz +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\LogSystem;.\SYSTEM\timers;.\SYSTEM\CheckSystem;.\FWLIB\inc;.\HARDWEAR\LED_Board;.\HARDWEAR;.\HARDWEAR\OLED;.\HARDWEAR\Motor;.\HARDWEAR\GD;.\HARDWEAR\Encoder;.\HARDWEAR\Servo;.\HARDWEAR\OpenMV;.\HARDWEAR\MPU6050;.\HARDWEAR\HC05;.\ALGORITHM\SpeedPID;.\ALGORITHM\Action;.\ALGORITHM\Turn;.\ALGORITHM\GDPID;.\HARDWEAR\FMQ;E:\keil\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/sys/: sys.c sys.h
    ./SYSTEM/timers/: timers.c timers.h
    ./SYSTEM/usart/: usart.c usart.h
  group HARDWEAR
    ./HARDWEAR/Encoder/: Encoder.c Encoder.h
    ./HARDWEAR/GD/: GD.c GD.h
    ./HARDWEAR/Motor/: Motor.c Motor.h
    ./HARDWEAR/OLED/: oled.c oled.h oledfont.h
    ./HARDWEAR/Servo/: Servo.c Servo.h
    ./HARDWEAR/MPU6050/: MPU6050.h MPU6050.c
    ./HARDWEAR/HC05/: HC05.c HC05.h
    ./HARDWEAR/FMQ/: FMQ.c FMQ.h
    ./HARDWEAR/: csb.c csb.h key.c key.h
  group Algorithm
    ./ALGORITHM/SpeedPID/: SpeedPID.c SpeedPID.h
    ./ALGORITHM/Action/: Action.c Action.h
